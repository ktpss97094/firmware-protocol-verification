# Keil uVision project COPD.uvprojx, settings and files
target COPD (6160000::V6.16::ARMCLANG)
  device: EFM32GG11B420F2048GM64 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32GG11B_DFP.3.2.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: COPD +hex
  AfterMake: fromelf.exe --bin --output Objects\COPD.bin Objects\COPD.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: EFM32GG11B420F2048GM64 DEBUG_EFM
  c include: ..\COPD;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\platform\emlib\inc;.\inc;..\..\..\platform\base\hal\plugin\debug\rtt;.\emlib\inc;C:\Users\Rpin\AppData\Local\Arm\Packs\ARM\CMSIS\5.5.1\CMSIS\Include;.\edge-impulse-sdk;.\model-parameters;.\tflite-model;..\copd-master;.\edge-impulse-sdk\classifier
  asm define: EFM32GG11B420F2048GM64 DEBUG_EFM
  asm include: ..\COPD;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include;..\..\..\platform\emlib\inc;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ./RTE/Device/EFM32GG11B420F2048GM64/: startup_efm32gg11b.s system_efm32gg11b.c
  group emlib
    ./emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_can.c em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_csen.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_iadc.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_pdm.c em_prs.c em_qspi.c em_rmu.c em_rtc.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_vcmp.c em_vdac.c em_wdog.c
  group Source
    ./: main.c
  group inc
    ./inc/: function.h i2s.h led.h example.h Adc.h CCS811.h gpiointerrupt.h HDC2080.h i2c.h LSM9DS1.h sdio.h usart.h
  group src
    ./src/: function.c i2s.c led.c example.c Adc.c CCS811.c gpiointerrupt.c HDC2080.c i2c.c LSM9DS1.c sdio.c usart.c
